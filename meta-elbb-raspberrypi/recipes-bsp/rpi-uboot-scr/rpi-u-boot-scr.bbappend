FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE = "rpi"